# Keil uVision project Pin Based Password System.uvproj, settings and files
target Target 1 (MCS-51)
  device: HT80C51 Handshake Solutions
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(60500000)
  output: Pin Based Password System +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Pin Based Password System.c
